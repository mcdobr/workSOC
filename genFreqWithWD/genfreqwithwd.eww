<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\genFreqWithWD.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\timpUltimulReset\timpultimulreset.ewp</path>
  </project>
  <batchBuild/>
</workspace>


